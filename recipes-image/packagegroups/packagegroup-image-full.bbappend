RDEPENDS_${PN}_remove = " \
    dragon \
"
